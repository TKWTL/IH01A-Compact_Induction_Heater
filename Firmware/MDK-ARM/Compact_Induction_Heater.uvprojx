# Keil uVision project Compact_Induction_Heater.uvprojx, settings and files
target Compact_Induction_Heater (6240000::V6.24::ARMCLANG)
  device: STM32G071CBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Compact_Induction_Heater +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32G071xx,USBPD_PORT_COUNT=1,_SNK,USBPDCORE_LIB_PD3_FULL,USE_HAL_DRIVER
  c include: ../Core/Inc;../APP;../APP/algorithm;../APP/MiaoUI;../APP/framework;../BSP/Buttons;../BSP/Display;../BSP/Console;../APP/PowerControl;../Peripheral/Time;./Scheduler;../ThirdParty/u8g2;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../USBPD/App;../USBPD/Target;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../ST_USBPD_Library_v541/Core/inc;../ST_USBPD_Library_v541/Devices/STM32G0XX/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\Ld\Compact_Induction_Heater.sct
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s retarget.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c comp.c crc.c dac.c dma.c i2c.c rtc.c spi.c tim.c ucpd.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_gpio.c stm32g0xx_ll_exti.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_ll_rcc.c stm32g0xx_ll_utils.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_comp.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_dac.c stm32g0xx_hal_dac_ex.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_dma.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Application/User/USBPD/Target
    ../USBPD/Target/: usbpd_dpm_user.c usbpd_pwr_user.c
  group Application/User/USBPD/App
    ../USBPD/App/: usbpd.c usbpd_pwr_if.c usbpd_dpm_core.c
  group ST/USBPD_v541
    ../ST_USBPD_Library_v541/Core/lib/: USBPDCORE_PD3_FULL_CM0PLUS_Keil.lib
    ../ST_USBPD_Library_v541/Core/src/: usbpd_trace.c
    ../ST_USBPD_Library_v541/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group IH01A/APP
    ../APP/: app_tasks.c
    ../APP/MiaoUI/core/: ui.c
    ../APP/MiaoUI/display/: dispDriver.c
    ../APP/MiaoUI/indev/: indevDriver.c
    ../APP/MiaoUI/fonts/: fonts.c
    ../APP/MiaoUI/images/: image.c
    ../APP/MiaoUI/: ui_conf.c pd_ui.c
    ../APP/MiaoUI/widget/: parameter.c text.c
  group PowerControl
    ../APP/PowerControl/: conv_adc.c conv_controller.c conv_phase.c conv_zcd.c conv_protection.c dashboard.c heater_control.c heater_budget.c heater_ui.c temp_service.c
  group IH01A/APP/algorithm/PD
    ../APP/algorithm/: pd_input.c pd_select.c pd_source_stats.c pd_diag.c ntc_lut.c
  group IH01A/APP/framework
    ../APP/framework/: pm_api.c pm_policy.c pm_controller.c pm_device.c pm_device_builtin.c pm_sleep_timer.c pm_ui_register.c system.c beep.c beep_hw.c time_service.c
  group IH01A/BSP+Time+Scheduler
    ../BSP/Buttons/: buttons.c
    ../BSP/Display/: ssd1315_display.c
    ../Peripheral/Time/: time_api.c
    ./Scheduler/: coroOS.c
    ../BSP/Console/: mini_format.c console_cli.c
  group IH01A/u8g2
    ../ThirdParty/u8g2/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_hvline.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_setup.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_d_ssd1315_128x64.c u8x8_display.c u8x8_gpio.c u8x8_setup.c u8x8_string.c
software components: CMSIS:CORE 6.2.0
